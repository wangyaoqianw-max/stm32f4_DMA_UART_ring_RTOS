# Keil uVision project RTT_elog_DMA_UART_ring_project.uvprojx, settings and files
target RTT_elog_DMA_UART_ring_project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RTT_elog_DMA_UART_ring_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,LV_CONF_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../05_vendors/RTT;../05_vendors/easylogger/inc;../05_vendors/easylogger/plugins/file;../05_vendors/easylogger/plugins/flash;../04_Impl/impl_middleware/impl_log;../03_Platform/platform_middleware;../03_Platform/platform_common;../03_Platform/platform_os;../03_Platform/platform_mcu/uart;../03_Platform/platform_mcu/gpio;../03_Platform/platform_mcu/i2c;../03_Platform/platform_mcu/spi;../03_Platform/platform_bsp;../03_Platform/platform_bsp/button;../03_Platform/platform_bsp/dht20;../03_Platform/platform_bsp/mpu6050;../03_Platform/platform_bsp/st7789;../03_Platform/platform_graphics;../03_Platform/platform_graphics/font;../04_Impl/impl_mcu;../04_Impl/impl_os/freertos;../04_Impl/impl_board;../02_Service/service_common;../02_Service/service_uart;../02_Service/service_log;../02_Service/service_indicator;../02_Service/service_button;../02_Service/service_acquisition;../00_Config;../01_APP;..\03_Platform\platform_bsp\cst816t;..\05_Vendors\lvgl;..\03_Platform\platform_gui;..\01_APP\ui;..\01_APP\ui\generated;..\01_APP\ui\custom
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group APP
    ../01_APP/: app_system.c app_communication.c app_control.c app_acquisition.c app_indicator.c app_display.c
    ../01_APP/ui/: ui_sensor_monitor.c
  group service/service_common
    ../02_Service/service_common/: ring_buffer.c
  group service/service_uart
    ../02_Service/service_uart/: service_uart.c
  group service/service_log
    ../02_Service/service_log/: service_log.c
  group service/service_indicator
    ../02_Service/service_indicator/: service_indicator.c
  group service/service_button
    ../02_Service/service_button/: service_button.c
  group service/service_acquisition
    ../02_Service/service_acquisition/: service_acquisition.c
  group platform/platform_common
    ../03_Platform/platform_common/: platform_object.c platform_device.c
  group platform/platform_mcu/uart
    ../03_Platform/platform_mcu/uart/: platform_uart.c
  group platform/platform_mcu/gpio
    ../03_Platform/platform_mcu/gpio/: platform_gpio.c
  group platform/platform_mcu/i2c
    ../03_Platform/platform_mcu/i2c/: platform_i2c.c platform_i2c.h
  group platform/platform_mcu/spi
    ../03_Platform/platform_mcu/spi/: platform_spi.c
  group platform/platform_bsp/st7789
    ../03_Platform/platform_bsp/st7789/: platform_st7789.c platform_bsp_st7789.c
  group platform/platform_gui
    ../03_Platform/platform_gui/: platform_gui.c
  group platform/platform_graphics
    ../03_Platform/platform_graphics/: platform_graphics.c
    ../03_Platform/platform_graphics/font/: platform_font_ascii_8x16.c
  group platform/platform_bsp/led
    ../03_Platform/platform_bsp/led/: platform_led.c platform_bsp_led.c
  group platform/platform_bsp/button
    ../03_Platform/platform_bsp/button/: platform_button.c platform_bsp_button.c
  group platform/platform_bsp/dht20
    ../03_Platform/platform_bsp/dht20/: platform_dht20.c platform_dht20.h
  group platform/platform_bsp/mpu6050
    ../03_Platform/platform_bsp/mpu6050/: platform_mpu6050.c platform_mpu6050.h
  group impl/impl_mcu
    ../04_Impl/impl_mcu/: impl_platform_uart.c impl_platform_gpio.c impl_platform_delay.c impl_platform_spi.c
  group impl/impl_bsp
    ../04_Impl/impl_bsp/: impl_platform_bsp_uart.c impl_platform_bsp_gpio.c impl_platform_bsp_spi.c
  group impl/impl_os/freertos
    ../04_Impl/impl_os/freertos/: impl_freertos_time.c impl_freertos_thread.c impl_freertos_mutex.c impl_freertos_semaphore.c impl_freertos_queue.c impl_freertos_notify.c impl_freertos_timer.c
  group platform/platform_middleware
    ../03_Platform/platform_middleware/: platform_log.h
  group impl/impl_middleware/impl_log
    ../04_Impl/impl_middleware/impl_log/: easylogger_port.c rtt_elog_port.c
  group vendors/RTT
    ../05_vendors/RTT/: SEGGER_RTT.c SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group vendors/easylogger
    ../05_vendors/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../05_vendors/easylogger/port/: elog_port.c
  group Platform_CST816T
    ../03_Platform/platform_bsp/cst816t/: platform_cst816t.c
  group vendors/lvgl/core
    ../05_Vendors/lvgl/src/core/: lv_group.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style_gen.c lv_obj_style.c lv_obj_tree.c lv_obj.c lv_refr.c
  group vendors/lvgl/display
    ../05_Vendors/lvgl/src/display/: lv_display.c
  group vendors/lvgl/draw
    ../05_Vendors/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../05_Vendors/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../05_Vendors/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../05_Vendors/lvgl/src/draw/dma2d/: lv_draw_dma2d_fill.c lv_draw_dma2d_img.c lv_draw_dma2d.c
    ../05_Vendors/lvgl/src/draw/espressif/ppa/: lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c lv_draw_ppa.c
    ../05_Vendors/lvgl/src/draw/eve/: lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_draw_eve.c lv_eve.c
    ../05_Vendors/lvgl/src/draw/: lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_draw.c lv_image_decoder.c
    ../05_Vendors/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_draw_nema_gfx.c lv_nema_gfx_path.c
    ../05_Vendors/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_draw_g2d.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../05_Vendors/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_draw_pxp.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../05_Vendors/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../05_Vendors/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c lv_draw_dave2d.c
    ../05_Vendors/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../05_Vendors/lvgl/src/draw/sw/blend/: lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend.c
    ../05_Vendors/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../05_Vendors/lvgl/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask_rect.c lv_draw_sw_mask.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c lv_draw_sw.c
    ../05_Vendors/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_draw_vg_lite.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
  group vendors/lvgl/font
    ../05_Vendors/lvgl/src/font/: lv_binfont_loader.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14_aligned.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28_compressed.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_font.c
  group vendors/lvgl/indev
    ../05_Vendors/lvgl/src/indev/: lv_indev_gesture.c lv_indev_scroll.c lv_indev.c
  group vendors/lvgl/layouts
    ../05_Vendors/lvgl/src/layouts/flex/: lv_flex.c
    ../05_Vendors/lvgl/src/layouts/grid/: lv_grid.c
    ../05_Vendors/lvgl/src/layouts/: lv_layout.c
  group vendors/lvgl/libs
    ../05_Vendors/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../05_Vendors/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../05_Vendors/lvgl/src/libs/bmp/: lv_bmp.c
    ../05_Vendors/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok_impl.c xmltok_ns.c xmltok.c
    ../05_Vendors/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../05_Vendors/lvgl/src/libs/freetype/: lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_freetype.c lv_ftsystem.c
    ../05_Vendors/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../05_Vendors/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../05_Vendors/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../05_Vendors/lvgl/src/libs/gif/AnimatedGIF/src/: gif.c
    ../05_Vendors/lvgl/src/libs/gif/: lv_gif.c
    ../05_Vendors/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../05_Vendors/lvgl/src/libs/gltf/gltf_view/ibl/: lv_gltf_ibl_sampler.c
    ../05_Vendors/lvgl/src/libs/gstreamer/: lv_gstreamer.c
    ../05_Vendors/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../05_Vendors/lvgl/src/libs/libpng/: lv_libpng.c
    ../05_Vendors/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../05_Vendors/lvgl/src/libs/lz4/: lz4.c
    ../05_Vendors/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../05_Vendors/lvgl/src/libs/rle/: lv_rle.c
    ../05_Vendors/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../05_Vendors/lvgl/src/libs/svg/: lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c lv_svg.c
    ../05_Vendors/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../05_Vendors/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../05_Vendors/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../05_Vendors/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
  group vendors/lvgl/lv_init.c
    ../05_Vendors/lvgl/src/: lv_init.c
  group vendors/lvgl/misc
    ../05_Vendors/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../05_Vendors/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../05_Vendors/lvgl/src/misc/cache/: lv_cache_entry.c lv_cache.c
    ../05_Vendors/lvgl/src/misc/: lv_anim_timeline.c lv_anim.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color_op.c lv_color.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin_posix.c lv_profiler_builtin.c lv_rb.c lv_style_gen.c lv_style.c lv_templ.c lv_text_ap.c lv_text.c lv_timer.c lv_tree.c lv_utils.c
  group vendors/lvgl/osal
    ../05_Vendors/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os_none.c lv_os.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group vendors/lvgl/others
    ../05_Vendors/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../05_Vendors/lvgl/src/others/font_manager/: lv_font_manager_recycle.c lv_font_manager.c
    ../05_Vendors/lvgl/src/others/fragment/: lv_fragment_manager.c lv_fragment.c
    ../05_Vendors/lvgl/src/others/gridnav/: lv_gridnav.c
    ../05_Vendors/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../05_Vendors/lvgl/src/others/imgfont/: lv_imgfont.c
    ../05_Vendors/lvgl/src/others/monkey/: lv_monkey.c
    ../05_Vendors/lvgl/src/others/observer/: lv_observer.c
    ../05_Vendors/lvgl/src/others/snapshot/: lv_snapshot.c
    ../05_Vendors/lvgl/src/others/sysmon/: lv_sysmon.c
    ../05_Vendors/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev_gesture.c lv_test_indev.c lv_test_screenshot_compare.c
    ../05_Vendors/lvgl/src/others/translation/: lv_translation.c
    ../05_Vendors/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../05_Vendors/lvgl/src/others/xml/: lv_xml_base_types.c lv_xml_component.c lv_xml_load.c lv_xml_parser.c lv_xml_style.c lv_xml_test.c lv_xml_translation.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c lv_xml.c
    ../05_Vendors/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_qrcode_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_spinbox_parser.c lv_xml_switch_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
  group vendors/lvgl/stdlib
    ../05_Vendors/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../05_Vendors/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../05_Vendors/lvgl/src/stdlib/: lv_mem.c
    ../05_Vendors/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../05_Vendors/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../05_Vendors/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group vendors/lvgl/themes
    ../05_Vendors/lvgl/src/themes/default/: lv_theme_default.c
    ../05_Vendors/lvgl/src/themes/: lv_theme.c
    ../05_Vendors/lvgl/src/themes/mono/: lv_theme_mono.c
    ../05_Vendors/lvgl/src/themes/simple/: lv_theme_simple.c
  group vendors/lvgl/tick
    ../05_Vendors/lvgl/src/tick/: lv_tick.c
  group vendors/lvgl/widgets
    ../05_Vendors/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../05_Vendors/lvgl/src/widgets/animimage/: lv_animimage.c
    ../05_Vendors/lvgl/src/widgets/arc/: lv_arc.c
    ../05_Vendors/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../05_Vendors/lvgl/src/widgets/bar/: lv_bar.c
    ../05_Vendors/lvgl/src/widgets/button/: lv_button.c
    ../05_Vendors/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../05_Vendors/lvgl/src/widgets/calendar/: lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    ../05_Vendors/lvgl/src/widgets/canvas/: lv_canvas.c
    ../05_Vendors/lvgl/src/widgets/chart/: lv_chart.c
    ../05_Vendors/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../05_Vendors/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../05_Vendors/lvgl/src/widgets/image/: lv_image.c
    ../05_Vendors/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../05_Vendors/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../05_Vendors/lvgl/src/widgets/label/: lv_label.c
    ../05_Vendors/lvgl/src/widgets/led/: lv_led.c
    ../05_Vendors/lvgl/src/widgets/line/: lv_line.c
    ../05_Vendors/lvgl/src/widgets/list/: lv_list.c
    ../05_Vendors/lvgl/src/widgets/lottie/: lv_lottie.c
    ../05_Vendors/lvgl/src/widgets/menu/: lv_menu.c
    ../05_Vendors/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../05_Vendors/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../05_Vendors/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../05_Vendors/lvgl/src/widgets/roller/: lv_roller.c
    ../05_Vendors/lvgl/src/widgets/scale/: lv_scale.c
    ../05_Vendors/lvgl/src/widgets/slider/: lv_slider.c
    ../05_Vendors/lvgl/src/widgets/span/: lv_span.c
    ../05_Vendors/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../05_Vendors/lvgl/src/widgets/spinner/: lv_spinner.c
    ../05_Vendors/lvgl/src/widgets/switch/: lv_switch.c
    ../05_Vendors/lvgl/src/widgets/table/: lv_table.c
    ../05_Vendors/lvgl/src/widgets/tabview/: lv_tabview.c
    ../05_Vendors/lvgl/src/widgets/textarea/: lv_textarea.c
    ../05_Vendors/lvgl/src/widgets/tileview/: lv_tileview.c
    ../05_Vendors/lvgl/src/widgets/win/: lv_win.c
  group GUI_Guider_Generated
    ../01_APP/ui/generated/assets/fonts/: lv_font_montserratMedium_10.c lv_font_montserratMedium_12.c lv_font_montserratMedium_14.c lv_font_montserratMedium_24.c
    ../01_APP/ui/generated/events/: gg_event_layer_bottom.c gg_event_layer_sys.c gg_event_layer_top.c gg_event_screen.c
    ../01_APP/ui/generated/: gg_utils.c
    ../01_APP/ui/generated/screens/: gg_layer_bottom.c gg_layer_sys.c gg_layer_top.c gg_screen.c
software components: CMSIS:CORE 4.3.0
